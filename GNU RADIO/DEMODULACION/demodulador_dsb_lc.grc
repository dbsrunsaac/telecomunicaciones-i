options:
  parameters:
    author: Bremdows
    generate_options: qt_gui
    id: demodulador_dsb_lc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Selector
  id: variable_qtgui_chooser
  parameters:
    label: tono_musica
    label0: Tono
    label1: Musica
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: raw
    value: '1'
  states: {}
- name: freq_Tono
  id: variable_qtgui_range
  parameters:
    label: Frecuencia moduladora
    start: '300'
    step: '25'
    stop: '1000'
    value: '450'
  states: {}
- name: freq_filtro_Rx
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del Filtro
    start: '3000'
    step: '200'
    stop: '60000'
    value: '4200'
  states: {}
- name: freq_portadora
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del Filtro
    start: 530e3
    step: '100'
    stop: 1700e3
    value: 530e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_portadora
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: Selector
    type: float
  states: {}
- name: graficas
  id: qtgui_tab_widget
  parameters:
    label0: Tiempo
    label1: Frecuencia
    num_tabs: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: freq_Tono
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: freq_filtro_Rx
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'graficas@1: 1,0'
    name: '"Grafica 2"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: graficas@1:0,1
    name: '"Grafica 4"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'graficas@0: 1,0'
    name: '"Grafica 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: graficas@0:0,1
    name: '"Grafica 3"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_xx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0, '1', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
