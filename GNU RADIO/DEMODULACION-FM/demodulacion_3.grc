options:
  parameters:
    author: Bremdow
    generate_options: qt_gui
    id: demodulacion_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '10'
    value: '2'
  states: {}
- name: central_freq
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 102.1e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: '96500000'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: freq_central
  id: variable
  parameters:
    value: '96500000'
  states: {}
- name: root_rate
  id: variable_qtgui_range
  parameters:
    label: Cuadrature Rate
    start: 100e3
    step: 1e3
    stop: 600e3
    value: 400e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 48e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 5e6
    fc: central_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '400'
    interp: '48'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: central_freq
    dev_addr: '"addr=192.168.10.2"'
    gain0: '1'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
