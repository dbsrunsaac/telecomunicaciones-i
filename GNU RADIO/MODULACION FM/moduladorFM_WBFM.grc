options:
  parameters:
    author: Bremdows
    generate_options: qt_gui
    id: moduladorFM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_trans
  id: variable_qtgui_range
  parameters:
    start: 85e6
    step: 100e3
    stop: 86e7
    value: 86e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_trans
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_trans
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_trans*10
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '150e-3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_trans
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Bremdows\UNSAAC\SEMESTRE VII\TELECOMUNICACIONES I\telecomunicaciones-i\GNU RADIO\MODULACION FM\canto-ancestral.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '2'
    gain: '1'
    samp_rate: samp_trans*10
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs_mod@3
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs_mod@1
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs_mod@0
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: yellow
    gui_hint: tabs_mod@2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tabs_mod
  id: qtgui_tab_widget
  parameters:
    label0: Moduladora - Tiempo
    label1: Moduladora - Frecuencia
    label2: Modulada - Tiempo
    label3: Modulada - Frecuencia
    num_tabs: '4'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_trans
    dev_addr: '"addr=192.168.10.3"'
    gain0: '0'
    samp_rate: samp_trans*10
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
